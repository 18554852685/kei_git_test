# Keil uVision project STM32-DEMO.uvprojx, settings and files
target Temlate-DEMO (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\modbus\ascii;..\modbus\include;..\modbus\rtu;..\modbus\tcp;..\modbus\port;..\SYSTEM\ADC;..\SYSTEM\delay;..\SYSTEM\KEY;..\SYSTEM\LED;..\SYSTEM\TIMER;..\SYSTEM\mcp6s28SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_spi.c
  group CMSIS
    ../FWlib/src/: misc.c
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group modbus
    ../modbus/tcp/: mbtcp.c
    ../modbus/rtu/: mbcrc.c mbrtu.c
    ../modbus/ascii/: mbascii.c
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../modbus/: mb.c
  group modbusport
    ../modbus/port/: portevent.c portserial.c porttimer.c
  group New Group
    ../SYSTEM/ADC/: adc.c
    ../SYSTEM/KEY/: key.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/LED/: led.c
    ../SYSTEM/mcp6s28SPI/: mcp6s28SPI.c
